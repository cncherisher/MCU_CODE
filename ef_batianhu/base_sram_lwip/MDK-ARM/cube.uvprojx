# Keil uVision project cube.uvprojx, settings and files
target Iwip (6160000::V6.16::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: cube +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Middlewares;..\Middlewares\lwip\src\include;..\Middlewares\lwip\arch;..\Middlewares\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c fsmc.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c led.c key.c eth_port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_eth.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/lwip/src/api
    ../Middlewares/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/lwip/src/core
    ../Middlewares/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/lwip/src/netif
    ../Middlewares/lwip/src/netif/: ethernet.c
  group Middlewares/lwip/arch
    ../Middlewares/lwip/arch/: ethernetif.c lwip_comm.c
  group Middlewares/malloc
    ../Middlewares/malloc/: malloc.c
software components: CMSIS:CORE 6.1.0
